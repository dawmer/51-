# Keil uVision project template.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: template +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\四路采集串口显示
  group Source Group 1
    ./: main.c zdinit.c oled.c ds1302.c
    ./四路采集串口显示/: DA-AD.C I2C.c
